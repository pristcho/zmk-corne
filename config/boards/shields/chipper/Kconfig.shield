## config/boards/shields/chipper/Kconfig.shield
```kconfig
# Copyright (c) 2020 Pete Johanson
# SPDX-License-Identifier: MIT

config SHIELD_CHIPPER
	def_bool $(shields_list_contains,chipper)
```
